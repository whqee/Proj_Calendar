# Keil uVision project calendar.uvproj, settings and files
target Core (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: calendar +hex
  c flags: Optimize=8 SizeSpeed=1
  group system
    ./: STARTUP.A51
  group Drivers
    ./: lcd1602.c ds1302.h ds1302.c lcd1602.h
  group Application
    ./: main.c common.h
